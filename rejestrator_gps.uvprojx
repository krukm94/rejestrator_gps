# Keil uVision project rejestrator_gps.uvprojx, settings and files
target rejestrator_gps (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rejestrator_gps +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32L4_NUCLEO
  c include: .\lib;.\lib\cmsis;.\lib\hal\Inc;.\lib\hal\Inc\Legacy;.\src;.\lib\hal\Src;.\lib\usb_dev\core\Inc;.\lib\usb_dev\class\Inc;.\lib\FatFs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group lib
    ./lib/: stm32l4xx_it.c
    ./lib/cmsis/: system_stm32l4xx.c startup_stm32l476xx.s
  group src
    ./src/: main.c init.c gpio.c service_uart.c gps.c timer.c pwr.c bmi160.c usb.c usbd_desc.c usbd_conf.c usbd_storage_if.c AK_stm32_fatfs.c
  group hal_ll
    ./lib/hal/Src/: stm32l4xx_ll_gpio.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_ll_rcc.c stm32l4xx_hal_sd.c stm32l4xx_hal_dma.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_spi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_ll_dma.c stm32l4xx_hal_adc.c stm32l4xx_ll_adc.c stm32l4xx_hal_adc_ex.c
  group usb_dev
    ./lib/usb_dev/core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ./lib/usb_dev/class/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group FatFs
    ./lib/FatFs/: diskio.c fatfs_sd_sdio.c ff.c
    ./lib/FatFs/option/: syscall.c unicode.c
